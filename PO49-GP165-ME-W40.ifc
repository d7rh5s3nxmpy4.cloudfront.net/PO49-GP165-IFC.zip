Properties of the parts of a building model (IFC2X3)

# File
Time: 2019-01-15T04:34:36
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (2)
Name | FlowDirection
 | SOURCE
 | SINK

# IfcFlowTerminal: PO49-GP165-ME-4W40
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT

# IfcFlowTerminal: PowerMission 4 Street lighting LED
In: Default Building
Type - Description: Engineered from the base up with environmental consciousness and energy effi ciency in mind, LIGMAN’s PowerMission series, developed specifically to fulfi ll the demanding conditions of road and street lighting applications, are highly fl exible and can be easily retrofi tted onto existing street lighting infrastructure making it a state-of-theart technology that is practical and affordable.Industry leading optical technology that minimizes light pollution and optimizes light distribution ensures that only the targeted areas are illuminated, reducing unwanted light trespass and sky glow. This characteristic ensures PowerMission’s compliance to the Dark Sky requirements. The luminaire rated as CLASS I with integral driver. Colour temperature 3000K and 4000K, LED CRI >80 and life time 50,000 Hours. A high quality die-casted aluminum casting not only houses the control gear and the light modules but it also acts as the primary thermal management device, eliminating the need for additional and sometimes bulky heat sinks while improving the overall performance and extending the life span of the LEDs. Lamp:72 LED LED colour :4000K Power :160 w. Weight :18.1 kg. IP66 /EN 60598/CLASS III / CE /IK07; PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: PowerMission, Street and area lighting luminaire; Housing color: All
General Information - Weight: 18.1 kg; Case length: 79.8 cm; Case width: 43 cm; Case height: 14.4 cm; Article name: PowerMission 4 Street lighting LED; Uld creation date: 15.01.2019 03:34:36
Photometric Information - Light output ratio: 0.999971; Luminous flux: 11877.4 lm; Lamp names: PO49-GP165-ME-4W40
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 160 W
Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 160 W; LightFixtureMountingType: Standing; LightFixturePlacingType: Floor; ManufacturersSpecificInformation: LIGMAN
Pset_LampTypeCommon - ContributedLuminousFlux: 11877.4 lm; LightEmitterNominalPower: 160 W; Spectrum: 380: 0.012934, 385: 0.01155, 390: 0.011614, 395: 0.010494, 400: 0.010484, 405: 0.010279, 410: 0.00968, 415: 0.011352, 420: 0.017493, 425: 0.049381, 430: 0.110001, 435: 0.213323, 440: 0.422394, 445: 0.673726, 450: 0.939462, 455: 0.97829, 460: 0.851938, 465: 0.670014, 470: 0.549521, 475: 0.442322, 480: 0.39367, 485: 0.37832, 490: 0.392506, 495: 0.423255, 500: 0.468951, 505: 0.509823, 510: 0.551923, 515: 0.57673, 520: 0.59894, 525: 0.611155, 530: 0.623829, 535: 0.629598, 540: 0.636475, 545: 0.645361, 550: 0.655589, 555: 0.671682, 560: 0.690295, 565: 0.709359, 570: 0.730587, 575: 0.748998, 580: 0.767832, 585: 0.786295, 590: 0.801043, 595: 0.812518, 600: 0.821303, 605: 0.827334, 610: 0.827494, 615: 0.819016, 616: 0.814072, 617: 0.810179, 618: 0.806287, 619: 0.802012, 620: 0.797737, 625: 0.764787, 630: 0.724964, 635: 0.680899, 640: 0.638133, 645: 0.594845, 650: 0.555125, 655: 0.51894, 660: 0.486181, 665: 0.454614, 670: 0.422297, 675: 0.388355, 680: 0.352992, 685: 0.318193, 690: 0.282697, 695: 0.245701, 700: 0.215906, 705: 0.189853, 710: 0.163229, 715: 0.14476, 720: 0.12737, 725: 0.114158, 730: 0.097674, 735: 0.085444, 740: 0.075708, 745: 0.068751, 750: 0.061453, 755: 0.056451, 760: 0.052251; ColorTemperature: 3114 K; ColorAppearance: 3783 K
